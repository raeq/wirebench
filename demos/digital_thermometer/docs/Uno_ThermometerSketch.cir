.TITLE Uno_ThermometerSketch
.END
